EXTRA_OECONF_append_armv7m = " --with-arch=armv7-m --with-mode=thumb "
