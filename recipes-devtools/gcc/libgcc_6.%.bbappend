EXTRA_OECONF:remove =   "--enable_multilib"
EXTRA_OECONF:append =   " --disable-multilib"

