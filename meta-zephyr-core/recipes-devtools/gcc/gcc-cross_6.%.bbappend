EXTRA_OECONF:append:armv7m = " --with-arch=armv7-m --with-mode=thumb "
