SUMMARY = "Hello World Zephyr Sample"
DESCRIPTION = "A simple Zephyr application that prints 'Hello World' on the \
console"

include zephyr-sample.inc

ZEPHYR_SRC_DIR = "${S}/samples/hello_world"
