include zephyr-sample.inc

ZEPHYR_SRC_DIR = "${ZEPHYR_BASE}/samples/subsys/ipc/openamp/remote"

COMPATIBLE_MACHINE = "(mimx8mq_evk_cm4)"
